# Keil uVision project KEY.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: KEY +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x_FWLib;..\sourse;..\USER;..\STM32F10x_FWLib\src;..\STM32F10x_FWLib\inc;..\CM3\CoreSupport;..\CM3\DeviceSupport
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../sourse/: main.c stm32f10x_it.c
  group CORE
    ../CM3/CoreSupport/: core_cm3.h
    ../CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ../sourse/: system_stm32f10x.c
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
